# Keil uVision project Keil_OTA_Boot.uvprojx, settings and files
target Keil_OTA_Boot (6220000::V6.22::ARMCLANG)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: Keil_OTA_Boot +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=6 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c misc: -Wno-unsafe-buffer-usage -Wno-padded -Wno-format-nonliteral
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../MCUBoot/port;../MCUBoot/bootutil/include;../MCUBoot/tinycrypt/lib/include;../MCUBoot/mbedtls-asn1/include
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c usart.c boot_ota.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_uart.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group MCUBoot/bootutil
    ../MCUBoot/bootutil/src/: bootutil_area.c bootutil_find_key.c bootutil_img_hash.c bootutil_img_security_cnt.c bootutil_loader.c bootutil_misc.c bootutil_public.c fault_injection_hardening.c image_ecdsa.c image_validate.c loader.c swap_misc.c swap_scratch.c tlv.c
  group MCUBoot/tinycrypt
    ../MCUBoot/tinycrypt/lib/source/: ecc.c ecc_dsa.c sha256.c utils.c
  group MCUBoot/mbedtls-asn1
    ../MCUBoot/mbedtls-asn1/src/: asn1parse.c platform_util.c
  group MCUBoot/port
    ../MCUBoot/port/: flash_map.c boot_log.c keys.c boot_nv_counter.c crypto_stubs.c
software components: CMSIS:CORE 4.3.0
